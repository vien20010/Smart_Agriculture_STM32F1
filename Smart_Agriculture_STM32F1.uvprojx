# Keil uVision project Smart_Agriculture_STM32F1.uvprojx, settings and files
target Smart_Agriculture_STM32F1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart_Agriculture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Src;.\STM32F10x_StdPeriph_Driver\inc;.\Mylib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Src/: system_stm32f10x.c
  group User
    ./Src/: main.c stm32f10x_it.c
  group Std_Lib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_gpio.c
  group Startup
    ./Src/: startup_stm32f10x_md.s
  group Mylib
    ./Mylib/: MAX44009.c Systick.c I2C.c GPIO.c DS18B20.c Timerx.c DHT11.c Uart.c
software components: CMSIS:CORE 5.2.0
